# Keil uVision project STM32F429.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  AfterMake: fromelf --bin --output  ..\Output\STM32F429.bin  ..\Output\STM32F429.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED=1,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Driver\LED;..\Driver\DELAY;..\Driver\SDRAM;..\Driver\USART;..\Driver\TOUCH;..\Driver\LCD;..\RT-Thread\include\libc;..\RT-Thread\include;..\RT-Thread\components\finsh;..\RT-Thread\bsp;..\STemWin5.40;..\STemWin5.40\inc;..\STemWin5.40\Config;..\STemWin5.40\Application;..\DspLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\Output\STM32F429.sct
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F429_Periph_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DRIVER
    ../Driver/LED/: led.c
    ../Driver/DELAY/: delay.c
    ../Driver/SDRAM/: sdram.c
    ../Driver/USART/: usart.c
    ../Driver/TOUCH/: touch_043.c touch_iic.c
    ../Driver/LCD/: lcd_rgb.c
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../RT-Thread/bsp/: board.c
  group RTT/Source
    ../RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group RTT/Ports
    ../RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group EMWIN_Config
    ../STemWin5.40/Config/: emWin_Drive.c GUIConf.c
    ../STemWin5.40/: GUI_Touch.c
    ../STemWin5.40/OS/: GUI_X_OS.c
  group EMWIN_LIB
    ../STemWin5.40/Lib/: STemWin540_CM4_OS_Keil_ot.lib
  group EMWIN_DEMO
    ../STemWin5.40/Application/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group DSP_LIB
    ../DspLib/: arm_cortexM4lf_math.lib
